# IAR project mydemo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207RB STM8S207RB
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: ..\include; ..\lib\inc; ..\lib\src; ..\driver; ..\scene; ..\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: mydemo.hex
  ILINK.IlinkOutputFile: mydemo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group driver
    ../driver/: arch.c exti.c iwdg.c tim1.c uart.c w25x16.c wwdg.c
  group lib
    ../lib/src/: stm8s_adc2.c stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim3.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
    ../driver/: stm8s_interruput.c
  group scene
    ../scene/: charQue.c driver.c f_bluetooth.c f_finger.c f_idle.c f_LowPowerAlarm.c f_mngBluetooth.c f_mngfinger.c f_mngPsword.c f_mngQuery.c f_mngSystem.c f_poweron.c f_pswd.c f_remote.c f_set.c l_fingprint.c l_i2c_datetime.c l_i2c_touch.c l_oled.c l_queryRecord.c l_sleep.c l_voice.c sys.c
  group user
    ./: main.c
